# Keil uVision project SWD.uvproj, settings and files
target SWD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SWD +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: .\SYSTEM\delay;.\SYSTEM\sys;.\APP;.\HARDWARE\LCD;.\MALLOC;.\HARDWARE\TOUCH;.\HARDWARE\24CXX;.\GUI;.\FATFS\src;.\FATFS\exfuns;.\TEXT;.\HARDWARE\SDIO;.\HARDWARE\W25QXX;.\HARDWARE\SPI;.\HARDWARE\RTC;.\HARDWARE\CAN;.\HARDWARE\USART3;.\EMWIN\STemWin\Config;.\EMWIN\STemWin\inc;.\HARDWARE\IIC;.\HARDWARE\TOUCH;.\HARDWARE\LED;.\TOOLS;.\EMWIN\STemWinHZ
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ./: startup_stm32f10x_hd.s
  group APP
    ./APP/: main.c Public.c CanLinkUsart.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
  group HARDWARE
    ./HARDWARE/LCD/: ILI93xx.c
    ./HARDWARE/SDIO/: sdio_sdcard.c
    ./HARDWARE/W25QXX/: w25qxx.c
    ./HARDWARE/SPI/: spi.c
    ./HARDWARE/CAN/: Can.c
    ./HARDWARE/24CXX/: 24cxx.c
    ./HARDWARE/IIC/: myiic.c
    ./HARDWARE/TOUCH/: gt9147.c touch.c ctiic.c
    ./HARDWARE/LED/: Led.c
    ./HARDWARE/USART3/: Usart1.c
  group MALLOC
    ./MALLOC/: malloc.c
  group FATFS
    ./FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ./FATFS/src/: ff.c diskio.c
  group TEXT
    ./TEXT/: fontupd.c text.c
  group EMWIN_LIB
    ./EMWIN/STemWin/Lib/: STemWin526_CM3_Keil.lib
  group EMWIN_CONFIG
    ./EMWIN/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ./EMWIN/STemWin/OS/: GUI_X.c
  group TOOLS
    ./TOOLS/: TaskManger.c
  group EMWIN_HZ
    ./EMWIN/STemWinHZ/: GUI_FontHZ12.c GUI_FontHZ16.c GUI_FontHZ24.c GUI_UC_EncodeNone.c GUICharPEx.c
